SRC_URI = "file://scfw-ec_5.3.tar.gz"

S = "${WORKDIR}/scfw"

SC_FIRMWARE_NAME_mx8qm = "scfw_tcm.bin"

