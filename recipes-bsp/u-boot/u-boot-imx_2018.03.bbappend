UBOOT_SRC = "git://bitbucket.sw.nxp.com/mss/uboot-ecockpit.git;protocol=ssh"
SRCBRANCH = "ecockpit_4.14.78_1.0.0_ga-EC53-dev"
SRCREV = "ecockpit_05_03"
